Commit message: new meshes

File: assets/urdf/custom/vase.urdf (robot description, URDF)
Before this commit: robot tray, 1 links, 0 joints
Links:
- link tray_base_link: geometry collision mesh filename=meshes/bar_clamp.obj scale=5 5 5; visual mesh filename=meshes/bar_clamp.obj scale=5 5 5
